# Keil uVision project opl1000_app_m3.uvprojx, settings and files
target OPL1000_APP (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: opl1000_app_m3 +hex
  AfterMake: .\opl1000_app_m3.bat $L !L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__ OPL1000_APS
  c misc: --preinclude=sys_common.h
  c include: ..\..\..\..\APS\driver\chip\opl1000\hal_pwm;..\..\..\..\APS\driver\chip\opl1000\hal_spi;..\..\..\..\APS\driver\chip\opl1000\hal_system;..\..\..\..\APS\driver\chip\opl1000\hal_tick;..\..\..\..\APS\driver\chip\opl1000\hal_tmr;..\..\..\..\APS\driver\chip\opl1000\hal_dbg_uart;..\..\..\..\APS\driver\chip\opl1000\hal_uart;..\..\..\..\APS\driver\chip\opl1000\hal_vic;..\..\..\..\APS\driver\chip\opl1000\hal_wdt;..\..\..\..\APS\driver\CMSIS\Device\opl1000\Include;..\..\..\..\APS\driver\CMSIS\Include;..\..\..\..\APS\FreeRtos\Source\include;..\..\..\..\APS\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\..\..\APS\middleware\netlink\at;..\..\..\..\APS\middleware\netlink\cli;..\..\..\..\APS\middleware\netlink\data_flow;..\..\..\..\APS\middleware\netlink\diag_task;..\..\..\..\APS\middleware\netlink\msg;..\..\..\..\APS\middleware\netlink\mw_fim;..\..\..\..\APS\middleware\netlink\mw_ota;..\..\..\..\APS\middleware\netlink\ps_task;..\..\..\..\APS\project\opl1000\boot_sequence;..\..\..\..\APS\project\opl1000\include;..\..\..\..\APS\project\opl1000\startup;..\..\..\driver\chip\opl1000\hal_dbg_uart;..\..\..\driver\chip\opl1000\hal_patch;..\..\..\driver\chip\opl1000\hal_pwm;..\..\..\driver\chip\opl1000\hal_spi;..\..\..\driver\chip\opl1000\hal_system;..\..\..\driver\chip\opl1000\hal_tick;..\..\..\driver\chip\opl1000\hal_tmr;..\..\..\driver\chip\opl1000\hal_uart;..\..\..\driver\chip\opl1000\hal_vic;..\..\..\driver\chip\opl1000\hal_wdt;..\..\..\driver\CMSIS\Device\opl1000\Include;..\..\..\driver\CMSIS\Include;..\..\..\FreeRtos\Source\include;..\..\..\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\..\middleware\netlink\at;..\..\..\middleware\netlink\cli;..\..\..\middleware\netlink\data_flow;..\..\..\middleware\netlink\diag_task;..\..\..\middleware\netlink\msg;..\..\..\middleware\netlink\mw_fim;..\..\..\middleware\netlink\mw_ota;..\..\..\middleware\netlink\ps_task;..\..\..\project\common;..\..\..\project\opl1000\boot_sequence;..\..\..\project\opl1000\include;..\..\..\project\opl1000\startup
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  scatter file: .\opl1000_app_m3.sct
  link misc: --datacompressor off --entry=__Patch_EntryPoint
  group source
    ./: main_patch.c example.c
  group object
    ../../../../APS/targets/opl1000/object/: symdefs.o
    ../../../../APS/targets/opl1000/Output/Objects/: opl1000_patch_m3.lib opl1000_sdk_m3.lib
